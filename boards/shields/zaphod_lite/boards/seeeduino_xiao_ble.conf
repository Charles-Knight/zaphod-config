## boards/shields/zaphod_lite/boards/seeeduino_xiao_ble.conf
```kconfig
CONFIG_SPI=y

CONFIG_ZMK_DISPLAY=y
CONFIG_LV_USE_THEME_MONO=n
CONFIG_LV_COLOR_CHROMA_KEY_HEX=0x00FF00
```
